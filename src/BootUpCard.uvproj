# Keil uVision project BootUpCard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: BootUpCard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Main
    ./Main/: Program.c
  group Common
    ./Common/: Sleep.c I2C.c
  group HardWare
    ./HardWare/GUI/: GUI.c
    ./HardWare/LCD/: LCD.c
    ./HardWare/SerialPort/: Uart.c
    ./HardWare/EEPROM24C02/: EEPROM24C02.c
    ./HardWare/SdCard/: SdCard.c
    ./HardWare/SPI/: SPI.c
    ./HardWare/Sys/: Sys.c
    ./HardWare/Touch/: Touch.c
    ./HardWare/User/: Test.c
